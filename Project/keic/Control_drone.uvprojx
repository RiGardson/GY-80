# Keil uVision project Control_drone.uvprojx, settings and files
target control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Control_drone +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\keic;..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Lib\STM32F10x_StdPeriph_Driver\src;..\keic;..\..\Project;..\..\Lib\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group user
    ../: stm32f10x_it.c system_stm32f10x.c main.c
    ./: GPIO.c GPIO.h I2C.c I2C.h main.h mpu6050.c mpu6050.h RCC.c RCC.h RTC.c TIM.c
